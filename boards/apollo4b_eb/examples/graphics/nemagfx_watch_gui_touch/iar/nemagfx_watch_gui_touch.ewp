# IAR project nemagfx_watch_gui_touch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAP42KK-KBR AmbiqMicro AMAP42KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_PACKAGE_BGA; AM_PART_APOLLO4B; USE_TSI_MALLOC; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; PLATFORM=apollo4b_nemagfx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\portable\IAR\AMapollo2; ..\..\..\..\..\..\mcu\apollo4b\hal; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaGFX; ..\src; ..\..\..\..\..\..\utils; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\common\mem; ..\..\..\..\..\..\mcu\apollo4b; ..\..\..\..\..\..\CMSIS\ARM\Include; ..\..\..\..\..\..\devices; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaDC; ..\..\..\..\..\..\CMSIS\AmbiqMicro\Include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\NemaDC; ..\src\generated\NemaGUI; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\common; ..\..\..\..\..\..\third_party\FreeRTOSv10.1.1\Source\include; ..\..\..\..\..\..\third_party\ThinkSi\NemaGFX_SDK\include\tsi\NemaGFX; ..\src\generated; ..\..\..\..\..\..\boards\apollo4b_eb\bsp; ..\..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nemagfx_watch_gui_touch.bin
  ILINK.IlinkOutputFile: nemagfx_watch_gui_touch.out
  ILINK.IlinkIcfFile: linker_script.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\mcu\apollo4b\hal\mcu\iar\bin\libam_hal.a; ..\..\..\..\..\..\third_party\ThinkSi\config\apollo4b_nemagfx\iar\bin\lib_nema_apollo4b_nemagfx.a; ..\..\..\..\..\..\boards\apollo4b_eb\bsp\iar\bin\libam_bsp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; NEMAGFX_SDK_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK; AM_PACKAGE_BGA; AM_PART_APOLLO4B; USE_TSI_MALLOC; LD_LIBRARY_PATH=../../../../../third_party/ThinkSi/NemaGFX_SDK/lib; AM_FREERTOS; PLATFORM=apollo4b_nemagfx
  group (top)
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/IAR/AMapollo2/: port.c portasm.s
    ../src/: am_resources.c gui_task.c nemagfx_watch_gui_touch.c rtos.c
    ../../../../../../third_party/ThinkSi/config/apollo4b_nemagfx/: nema_dc_hal.c nema_event.c nema_hal.c nema_utils.c
    ../../../../../../devices/: am_devices_dsi_rm67162.c am_devices_nemadc_rm67162.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/portable/MemMang/: heap_4.c
    ../../../../../../utils/: am_util_delay.c am_util_stdio.c
    ../../../../../../third_party/FreeRTOSv10.1.1/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../src/generated/NemaGUI/: main.c
    ./: startup_iar.c
